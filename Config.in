## Config.in
```kconfig
config BR2_PACKAGE_RICOCHET
	bool "ricochet"
	help
	  Ricochet pitch shifter LV2 plugin

	  https://github.com/theKAOSSphere/ricochet
```
